# IAR project CortexM3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD
  ICCARM.CCIncludePath2: Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Libraries\STM32F10x_StdPeriph_Driver\inc; driver\include; fs\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CortexM3.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group CMSIS/Startup
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group Driver/ExtIF
    driver/extif/: extif.c
  group Driver/FND
    driver/fnd/: fnd.c
  group Driver/I2C_SW
    driver/i2c_sw/: i2c_sw.c
  group Driver/Key
    driver/key/: key.c
  group Driver/LCD
    driver/lcd/: lcd.c
  group Driver/LED
    driver/led/: led.c
  group Driver/RTC
    driver/rtc/: rtc.c
  group Driver/SDCard
    driver/sdcard/: sdcard.c
  group Driver/Sensor
    driver/sensor/: sensor.c
  group Driver/Serial
    driver/serial/: serial.c
  group Driver/System
    driver/system/: system.c
  group Driver/Timer
    driver/timer/: timer.c
  group Driver/Touch
    driver/touch/: touch.c
  group FileSystem/FAT
    fs/fat/: diskio.c ff.c
  group Library/Std_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
